# Keil uVision project NoneQuadrotor.uvprojx, settings and files
target NoneQuadrotor (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F765IITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.7.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: arducopter +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F765xx,USE_HAL_DRIVER
  c include: ..\Application;..\Drivers\LED;..\System\delay;..\System\sys;..\Communication\mavlink;..\Communication\mavlink\common;..\Drivers\UART;..\System;..\Drivers\IMU;..\Drivers\SPI;..\Drivers\SENSOR;..\Maths;..\System\sys;..\Communication\AnoProtocol;..\System\STM32F7xx_HAL_Driver\Inc;..\System;..\Drivers\RGBLED;..\Filter;..\Drivers\RGBLED;..\Drivers\RCIN;..\Algorithm\PID;..\Drivers\RCOUT;..\Algorithm\ATTITUDE;..\Drivers\FLASH;..\Drivers\RAM;..\Drivers\GPS;..\Drivers\SDCARD;..\Algorithm\ADRC;..\System\FATFS\exfuns;..\System\FATFS\src;..\Drivers\MALLOC;..\Drivers\BUZZER;..\Drivers\CAN;..\Algorithm\DCM
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group Application
    ../Application/: arducopter.c copter.c scheduler.c notice.c radio.c sensor.c motor.c
  group Algorithm
    ../Algorithm/PID/: pid.c
    ../Algorithm/ATTITUDE/: attitude.c
    ../Algorithm/ADRC/: adrc.c
    ../Algorithm/DCM/: ahrs_dcm.c
  group Drivers
    ../Drivers/RGBLED/: drv_ltr.c
    ../Drivers/LED/: drv_led.c
    ../Drivers/UART/: drv_uart.c
    ../Drivers/SPI/: drv_spi.c
    ../Drivers/SENSOR/: drv_sensor.c
    ../Drivers/IMU/: drv_ms5611.c drv_icm20602.c drv_icm20689.c drv_mpu6000.c drv_bmi055.c drv_iic.c drv_ist8310.c
    ../Drivers/RCIN/: drv_sbus.c drv_ppm.c
    ../Drivers/RCOUT/: drv_pwm.c
    ../Drivers/FLASH/: drv_flash.c
    ../Drivers/SDCARD/: drv_sdcard.c
    ../Drivers/RAM/: drv_fm25v01g.c
    ../Drivers/GPS/: drv_gps.c
    ../Drivers/MALLOC/: drv_malloc.c
    ../Drivers/BUZZER/: drv_buzzer.c
    ../Drivers/CAN/: drv_can.c
  group Filter
    ../Filter/: kalman.c
  group System
    ../System/sys/: sys.c
    ../System/: systick.c stm32f765_it.c system_stm32f7xx.c startup_stm32f765xx.s
    ../System/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_spi.c stm32f7xx_hal_dma.c stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_rcc.c stm32f7xx_hal_uart.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_sd.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c
  group Fatfs
    ../System/FATFS/src/: ff.c diskio.c
    ../System/FATFS/src/option/: cc936.c
    ../System/FATFS/exfuns/: exfuns.c fattester.c
  group Maths
    ../Maths/: lowpassfilter.c mathtool.c matrix3.c quaternion.c rotation.c vector3.c mathtype.c
  group Communication
    ../Communication/mavlink/: mavlink_usart_fifo.c open_tel_mavlink.c
    ../Communication/AnoProtocol/: ano_protocol.c
  group Readme
    ../Readme/: readme.txt
